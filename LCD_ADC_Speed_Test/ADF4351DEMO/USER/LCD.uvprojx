# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\KEY;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\LCD12864;..\HARDWARE\KeyBoard;..\HARDWARE\ADF4351;..\HARDWARE\ADC;..\HARDWARE\SPI;..\HARDWARE\PE4302;..\HARDWARE\DAC;..\HARDWARE\EXTI;..\emWin\;..\emWin\STemWinLibrary522\Config;..\emWin\STemWinLibrary522\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD12864/: LCD12864.c
    ../HARDWARE/KeyBoard/: KeyBoard.c
    ../HARDWARE/ADF4351/: ADF4351.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/PE4302/: PE4302.C
    ../HARDWARE/LCD/: ili93xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_spi.c
  group README
    ../: readme.txt
  group emWin
    ../emWin/: emWin_inc.h STemWin522_CM4_Keil.lib
    ../emWin/STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c GUIConf.h
    ../emWin/STemWinLibrary522/OS/: GUI_X.c
